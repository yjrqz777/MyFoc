# Keil uVision project g474app.uvprojx, settings and files
target g474app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: g474app +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Code;../Code/UserApp;../Code/UserBsp;../Code/UserBsp/ws2812;../Code/UserDrv;../Code/UserBsp/RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\g474app.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group UserApp
    ../Code/UserApp/: user_foc.c user_foc_math.c user_foc_pid.c user_smo.c user_motor.c user_motor_hall_vf.c user_display.c user_button.c user_button_fun.c user_system.c user_time.c
  group UserBsp
    ../Code/UserBsp/: bsp_adc.c bsp_pwm.c bsp_pwm_foc.c bsp_hall.c bsp_mt6816ct_acd.c bsp_lcd.c bsp_button.c
    ../Code/UserBsp/st7789v/: st7789v.c
    ../Code/UserBsp/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Code/UserBsp/ws2812/: bsp_ws2812.c
software components: CMSIS:CORE 6.1.0
